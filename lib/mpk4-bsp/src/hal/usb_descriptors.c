/* OPEN MPK4: USB descriptors. Same IDs and interface layout as the stock app (hardware map section 11) so the tools
 * find the unit: IF0 vendor HID (the flasher's C4 mode probe), IF1/IF2 stock USB MIDI 1.0 cable topology. */
#include "tusb.h"
#include "board.h"

enum { STR_LANG, STR_MANUFACTURER, STR_PRODUCT, STR_SERIAL };
static const tusb_desc_device_t dev = {
    .bLength = sizeof(tusb_desc_device_t), .bDescriptorType = TUSB_DESC_DEVICE, .bcdUSB = 0x0200,
    .bMaxPacketSize0 = CFG_TUD_ENDPOINT0_SIZE,
    .idVendor = 0x09E8, .idProduct = 0x005D, .bcdDevice = FW_VERSION_BCD,
    .iManufacturer = STR_MANUFACTURER, .iProduct = STR_PRODUCT, .iSerialNumber = STR_SERIAL, .bNumConfigurations = 1 };
uint8_t const *tud_descriptor_device_cb(void) { return (uint8_t const *)&dev; }

/* the stock (and OPENMPK3) vendor HID report descriptor: page 0xFFA0, 32-byte IN and OUT reports, no report ID */
static const uint8_t hid_report[] = {
    0x06, 0xA0, 0xFF, 0x09, 0x01, 0xA1, 0x01, 0x09, 0x02, 0xA1, 0x00, 0x06, 0xA1, 0xFF, 0x09, 0x03, 0x09, 0x04,
    0x15, 0x18, 0x25, 0x7F, 0x35, 0x00, 0x45, 0xFF, 0x75, 0x08, 0x95, 0x20, 0x81, 0x02, 0x09, 0x05, 0x09, 0x06,
    0x15, 0x80, 0x25, 0x7F, 0x35, 0x00, 0x45, 0xFF, 0x75, 0x08, 0x95, 0x20, 0x91, 0x02, 0xC0, 0xC0 };
uint8_t const *tud_hid_descriptor_report_cb(uint8_t instance) { (void)instance; return hid_report; }

// v1.43 application USB descriptor from scatter-loaded RAM at 0x20000738.
// Embedded jacks are listed in USB-MIDI cable order. The DIN jack is host-to-device only.
static const uint8_t cfg[] = {
    0x09, 0x02, 0xb0, 0x00, 0x03, 0x01, 0x00, 0x80, 0x32,
    0x09, 0x04, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00,
    0x09, 0x21, 0x10, 0x01, 0x00, 0x01, 0x22, 0x34, 0x00,
    0x07, 0x05, 0x81, 0x03, 0x20, 0x00, 0x01,
    0x07, 0x05, 0x01, 0x03, 0x20, 0x00, 0x01,
    0x09, 0x04, 0x01, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00,
    0x09, 0x24, 0x01, 0x00, 0x01, 0x09, 0x00, 0x01, 0x02,
    0x09, 0x04, 0x02, 0x00, 0x02, 0x01, 0x03, 0x00, 0x00,
    0x07, 0x24, 0x01, 0x00, 0x01, 0x6c, 0x00,
    0x06, 0x24, 0x02, 0x01, 0x01, 0x06,
    0x06, 0x24, 0x02, 0x01, 0x02, 0x07,
    0x06, 0x24, 0x02, 0x01, 0x03, 0x08,
    0x06, 0x24, 0x02, 0x01, 0x04, 0x09,
    0x06, 0x24, 0x02, 0x01, 0x05, 0x0a,
    0x09, 0x24, 0x03, 0x01, 0x06, 0x01, 0x01, 0x01, 0x06,
    0x09, 0x24, 0x03, 0x01, 0x07, 0x01, 0x02, 0x01, 0x07,
    0x09, 0x24, 0x03, 0x01, 0x08, 0x01, 0x03, 0x01, 0x08,
    0x09, 0x24, 0x03, 0x01, 0x09, 0x01, 0x04, 0x01, 0x09,
    0x09, 0x05, 0x02, 0x02, 0x40, 0x00, 0x00, 0x00, 0x00,
    0x09, 0x25, 0x01, 0x05, 0x01, 0x02, 0x03, 0x04, 0x05,
    0x09, 0x05, 0x82, 0x02, 0x40, 0x00, 0x00, 0x00, 0x00,
    0x08, 0x25, 0x01, 0x04, 0x06, 0x07, 0x08, 0x09,
};
TU_VERIFY_STATIC(sizeof cfg == 176, "configuration length");
uint8_t const *tud_descriptor_configuration_cb(uint8_t i) { return i == 0 ? cfg : NULL; }

uint16_t const *tud_descriptor_string_cb(uint8_t idx, uint16_t langid)
{
    (void)langid;
    static uint16_t buf[34];
    static const char *const names[] = {
        NULL, "Akai Professional", "MPK mini IV", NULL, "Device Interface",
        "Device Configuration", "MPK mini IV MIDI Port", "MPK mini IV DAW Port",
        "MPK mini IV Plugin Port", "MPK mini IV Software Control Port", "MPK mini IV Din Port",
    };
    if (idx == 0) {
        buf[0] = (TUSB_DESC_STRING << 8) | 4;
        buf[1] = 0x0409;
        return buf;
    }
    if (idx == STR_SERIAL) {
        const volatile uint8_t *serial = SETTINGS_PAGE;
        for (uint8_t i = 0; i < 16; ++i) buf[i + 1] = serial[i];
        buf[0] = (TUSB_DESC_STRING << 8) | 34;
        return buf;
    }
    if (idx >= sizeof names / sizeof names[0]) return NULL;
    const char *s = names[idx];
    uint8_t n = 0;
    for (; n < sizeof buf / sizeof buf[0] - 1 && s[n]; n++) buf[1 + n] = (uint8_t)s[n];
    buf[0] = (uint16_t)((TUSB_DESC_STRING << 8) | (2 * n + 2));
    return buf;
}

/* HID: the stock app answers only the mode probe 55 4F C4 with 55 49 E4 ("app running"); so do we */
void tud_hid_set_report_cb(uint8_t instance, uint8_t report_id, hid_report_type_t type, uint8_t const *b, uint16_t n)
{
    (void)report_id; (void)type;
    if (n >= 3 && b[0] == 0x55 && b[1] == 0x4F && b[2] == 0xC4) {
        uint8_t r[32] = { 0x55, 0x49, 0xE4 };
        tud_hid_n_report(instance, 0, r, sizeof r);
    }
}
uint16_t tud_hid_get_report_cb(uint8_t instance, uint8_t report_id, hid_report_type_t type, uint8_t *b, uint16_t n)
{
    (void)instance; (void)report_id; (void)type; (void)b; (void)n;
    return 0;
}
